Commit message: tuning pid controller for simulator

File: src/f1tenth_controllers/models/f1tenth_gazebo/model.urdf (robot description, URDF)
Before this commit: robot prius_hybrid, 4 links, 3 joints
Links:
- link base_link: mass 1326.0 -> 13.260
- link rear_axle: mass 30.0 -> 3.00
